# Keil uVision project superQucos.uvprojx, settings and files
target superQucos (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.6
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: superQucos
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx USE_STDPERIPH_DRIVER   __FPU_PRESENT=1  ARM_MATH_CM4
  c include: ..\CMSIS;..\Library\inc;..\Driver;..\Device;..\Dsp;..\User;..\uCOS\uC-Cfg;..\uCOS\uC-CPU;..\uCOS\uC-LIB;..\uCOS\uCOS-III;..\App;..\fatfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s system_stm32f4xx.c arm_common_tables.h arm_const_structs.h arm_math.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f4xx.h
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_can.c stm32f4xx_crc.c
  group Driver
    ../Driver/: Bsp.c function.c I2CH.c stm32f4xx_it.c crcTable.c
  group Device
    ../Device/: at25320.c Sdio_tf.c Sdio_test.c
  group Dsp
    ../Dsp/: arm_cortexM4lf_math.lib xbm_anti_trigonometric.c
  group User
    ../User/: main.c Global.h
  group uc_Cfg
    ../uCOS/uC-Cfg/: app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uc_Cpu
    ../uCOS/uC-CPU/: cpu_c.c cpu_core.c cpu_a.asm
  group uc_Lib
    ../uCOS/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c lib_mem_a.asm
  group uc_OSIII
    ../uCOS/uCOS-III/: os_cfg_app.c os_core.c os_cpu_c.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c os_cpu_a.asm
  group App
    ../App/: app.c appPresent.c appController.c appCommunicate.c appPath.c
  group fatfs
    ../fatfs/: diskio.c ff.c ff.h ffconf.h ff_driver.c
